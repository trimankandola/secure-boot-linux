FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://pmu.cfg"
